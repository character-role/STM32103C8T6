# Keil uVision project CKF.uvprojx, settings and files
target CKF (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TIM4PWM +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: .\Main;..\USER;..\CORE;..\FWLIB\inc;..\Periphery\IO;..\APP;..\Periphery\TIM;..\Periphery\AD;..\Periphery\WiFi;..\Periphery\SMotor;..\Periphery\DHT11;..\Periphery\SysTick
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./Main/: common.c
  group CORE
    ../CORE/: core_cm3.c system_stm32f10x.c stm32f10x_it.c
    ../CORE/startup/: startup_stm32f10x_md.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_sdio.c
  group Periphery
    ../Periphery/IO/: IO.c
    ../Periphery/AD/: AD.c
    ../Periphery/TIM/: TIM.c
    ../Periphery/WiFi/: WiFi.c
    ../Periphery/SysTick/: SysTick.c
    ../Periphery/SMotor/: SMotor.c
    ../Periphery/DHT11/: DHT11.c
  group APP
    ../APP/: app.c
